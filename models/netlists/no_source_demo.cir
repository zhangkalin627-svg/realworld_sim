* v0.11.1 演示：没有任何独立源的无源网表（常见于从整板 KiCad 原理图导出、电源/激励不在板上的情况）
* 软件应提示“无激励源，结果全零”，而不是显示“完成”
R1 a b 1k
C1 b 0 100n
R2 b c 10k
C2 c 0 10n
.tran 1u 2m
.end
